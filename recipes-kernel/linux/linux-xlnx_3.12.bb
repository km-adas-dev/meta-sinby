# See include file for common information
include linux-xlnx.inc

PR = "r1"

# Kernel version and SRCREV correspond to: 
# xilinx-v2013.4-trd tag 
LINUX_VERSION = "3.12"
SRCREV = "4f4ca924a1ed49b34ad95f26497778359cf0a5f1"

